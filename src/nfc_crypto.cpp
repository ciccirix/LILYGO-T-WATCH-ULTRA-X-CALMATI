
#include "nfc_crypto.h"
#include <string.h>

// Vendored verbatim from SCR-Terminal (gitlab.com/sacriphanius/scr-terminal),
// src/hal/nfc_crypto.cpp. ChameleonMini-style Crypto-1 (Even/Odd split LFSR,
// table-driven filter). The cipher is correct; only the reader auth that drives
// it (in mifare.cpp) is ours.

#define NO_INLINE_ASM 1

#define LFSR_MASK_EVEN   0x2010E1UL
#define LFSR_MASK_ODD    0x3A7394UL

#define FA(x3, x2, x1, x0) ( \
    ( (x0 | x1) ^ (x0 & x3) ) ^ ( x2 & ( (x0 ^ x1) | x3 ) ) \
)
#define FB(x3, x2, x1, x0) ( \
    ( (x0 & x1) | x2 ) ^ ( (x0 ^ x1) & (x2 | x3) ) \
)
#define FC(x4, x3, x2, x1, x0) ( \
    ( x0 | ( (x1 | x4) & (x3 ^ x4) ) ) ^ ( ( x0 ^ (x1 & x3) ) & ( (x2 ^ x3) | (x1 & x4) ) ) \
)

#define SPLIT_BYTE(__even, __odd, __byte) \
    __even = (__even >> 1) | (__byte<<7); __byte>>=1; \
    __odd  = (__odd  >> 1) | (__byte<<7); __byte>>=1; \
    __even = (__even >> 1) | (__byte<<7); __byte>>=1; \
    __odd  = (__odd  >> 1) | (__byte<<7); __byte>>=1; \
    __even = (__even >> 1) | (__byte<<7); __byte>>=1; \
    __odd  = (__odd  >> 1) | (__byte<<7); __byte>>=1; \
    __even = (__even >> 1) | (__byte<<7); __byte>>=1; \
    __odd  = (__odd  >> 1) | (__byte<<7)

#define SHIFT24(__b0, __b1, __b2, __in) \
    __b0 = (__b0>>1) | (__b1<<7); \
    __b1 = (__b1>>1) | (__b2<<7); \
    __b2 = (__b2>>1) | ((__in)<<7)

#define SHIFT8(__byte, __in)  __byte = (__byte>>1) | ((__in)<<7)

static const uint8_t OddByteParity[256] = {
    1, 0, 0, 1, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 0, 1,
    0, 1, 1, 0, 1, 0, 0, 1, 1, 0, 0, 1, 0, 1, 1, 0,
    0, 1, 1, 0, 1, 0, 0, 1, 1, 0, 0, 1, 0, 1, 1, 0,
    1, 0, 0, 1, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 0, 1,
    0, 1, 1, 0, 1, 0, 0, 1, 1, 0, 0, 1, 0, 1, 1, 0,
    1, 0, 0, 1, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 0, 1,
    1, 0, 0, 1, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 0, 1,
    0, 1, 1, 0, 1, 0, 0, 1, 1, 0, 0, 1, 0, 1, 1, 0,
    0, 1, 1, 0, 1, 0, 0, 1, 1, 0, 0, 1, 0, 1, 1, 0,
    1, 0, 0, 1, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 0, 1,
    1, 0, 0, 1, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 0, 1,
    0, 1, 1, 0, 1, 0, 0, 1, 1, 0, 0, 1, 0, 1, 1, 0,
    1, 0, 0, 1, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 0, 1,
    0, 1, 1, 0, 1, 0, 0, 1, 1, 0, 0, 1, 0, 1, 1, 0,
    0, 1, 1, 0, 1, 0, 0, 1, 1, 0, 0, 1, 0, 1, 1, 0,
    1, 0, 0, 1, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 0, 1
};

#define ODD_PARITY(x) OddByteParity[(x)]

uint8_t oddparity8(uint8_t x) { return OddByteParity[x]; }

static const uint8_t abFilterTable[3][256] = {
    {
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
        0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
        0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
        0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01
    },
    {
        0x00,0x00,0x00,0x02,0x02,0x00,0x00,0x02,0x00,0x02,0x02,0x02,0x02,0x00,0x00,0x02,
        0x00,0x00,0x00,0x02,0x02,0x00,0x00,0x02,0x00,0x02,0x02,0x02,0x02,0x00,0x00,0x02,
        0x00,0x00,0x00,0x02,0x02,0x00,0x00,0x02,0x00,0x02,0x02,0x02,0x02,0x00,0x00,0x02,
        0x04,0x04,0x04,0x06,0x06,0x04,0x04,0x06,0x04,0x06,0x06,0x06,0x06,0x04,0x04,0x06,
        0x04,0x04,0x04,0x06,0x06,0x04,0x04,0x06,0x04,0x06,0x06,0x06,0x06,0x04,0x04,0x06,
        0x00,0x00,0x00,0x02,0x02,0x00,0x00,0x02,0x00,0x02,0x02,0x02,0x02,0x00,0x00,0x02,
        0x00,0x00,0x00,0x02,0x02,0x00,0x00,0x02,0x00,0x02,0x02,0x02,0x02,0x00,0x00,0x02,
        0x04,0x04,0x04,0x06,0x06,0x04,0x04,0x06,0x04,0x06,0x06,0x06,0x06,0x04,0x04,0x06,
        0x00,0x00,0x00,0x02,0x02,0x00,0x00,0x02,0x00,0x02,0x02,0x02,0x02,0x00,0x00,0x02,
        0x04,0x04,0x04,0x06,0x06,0x04,0x04,0x06,0x04,0x06,0x06,0x06,0x06,0x04,0x04,0x06,
        0x04,0x04,0x04,0x06,0x06,0x04,0x04,0x06,0x04,0x06,0x06,0x06,0x06,0x04,0x04,0x06,
        0x04,0x04,0x04,0x06,0x06,0x04,0x04,0x06,0x04,0x06,0x06,0x06,0x06,0x04,0x04,0x06,
        0x04,0x04,0x04,0x06,0x06,0x04,0x04,0x06,0x04,0x06,0x06,0x06,0x06,0x04,0x04,0x06,
        0x00,0x00,0x00,0x02,0x02,0x00,0x00,0x02,0x00,0x02,0x02,0x02,0x02,0x00,0x00,0x02,
        0x00,0x00,0x00,0x02,0x02,0x00,0x00,0x02,0x00,0x02,0x02,0x02,0x02,0x00,0x00,0x02,
        0x04,0x04,0x04,0x06,0x06,0x04,0x04,0x06,0x04,0x06,0x06,0x06,0x06,0x04,0x04,0x06
    },
    {
        0x00,0x08,0x08,0x08,0x00,0x00,0x00,0x08,0x00,0x00,0x08,0x00,0x08,0x08,0x00,0x08,
        0x00,0x08,0x08,0x08,0x00,0x00,0x00,0x08,0x00,0x00,0x08,0x00,0x08,0x08,0x00,0x08,
        0x00,0x08,0x08,0x08,0x00,0x00,0x00,0x08,0x00,0x00,0x08,0x00,0x08,0x08,0x00,0x08,
        0x10,0x18,0x18,0x18,0x10,0x10,0x10,0x18,0x10,0x10,0x18,0x10,0x18,0x18,0x10,0x18,
        0x10,0x18,0x18,0x18,0x10,0x10,0x10,0x18,0x10,0x10,0x18,0x10,0x18,0x18,0x10,0x18,
        0x00,0x08,0x08,0x08,0x00,0x00,0x00,0x08,0x00,0x00,0x08,0x00,0x08,0x08,0x00,0x08,
        0x00,0x08,0x08,0x08,0x00,0x00,0x00,0x08,0x00,0x00,0x08,0x00,0x08,0x08,0x00,0x08,
        0x10,0x18,0x18,0x18,0x10,0x10,0x10,0x18,0x10,0x10,0x18,0x10,0x18,0x18,0x10,0x18,
        0x00,0x08,0x08,0x08,0x00,0x00,0x00,0x08,0x00,0x00,0x08,0x00,0x08,0x08,0x00,0x08,
        0x10,0x18,0x18,0x18,0x10,0x10,0x10,0x18,0x10,0x10,0x18,0x10,0x18,0x18,0x10,0x18,
        0x10,0x18,0x18,0x18,0x10,0x10,0x10,0x18,0x10,0x10,0x18,0x10,0x18,0x18,0x10,0x18,
        0x10,0x18,0x18,0x18,0x10,0x10,0x10,0x18,0x10,0x10,0x18,0x10,0x18,0x18,0x10,0x18,
        0x10,0x18,0x18,0x18,0x10,0x10,0x10,0x18,0x10,0x10,0x18,0x10,0x18,0x18,0x10,0x18,
        0x00,0x08,0x08,0x08,0x00,0x00,0x00,0x08,0x00,0x00,0x08,0x00,0x08,0x08,0x00,0x08,
        0x00,0x08,0x08,0x08,0x00,0x00,0x00,0x08,0x00,0x00,0x08,0x00,0x08,0x08,0x00,0x08,
        0x10,0x18,0x18,0x18,0x10,0x10,0x10,0x18,0x10,0x10,0x18,0x10,0x18,0x18,0x10,0x18
    }
};

static const uint8_t TableC0[32] = {
    FC(0,0,0,0,0),FC(0,0,0,0,1),FC(0,0,0,1,0),FC(0,0,0,1,1),
    FC(0,0,1,0,0),FC(0,0,1,0,1),FC(0,0,1,1,0),FC(0,0,1,1,1),
    FC(0,1,0,0,0),FC(0,1,0,0,1),FC(0,1,0,1,0),FC(0,1,0,1,1),
    FC(0,1,1,0,0),FC(0,1,1,0,1),FC(0,1,1,1,0),FC(0,1,1,1,1),
    FC(1,0,0,0,0),FC(1,0,0,0,1),FC(1,0,0,1,0),FC(1,0,0,1,1),
    FC(1,0,1,0,0),FC(1,0,1,0,1),FC(1,0,1,1,0),FC(1,0,1,1,1),
    FC(1,1,0,0,0),FC(1,1,0,0,1),FC(1,1,0,1,0),FC(1,1,0,1,1),
    FC(1,1,1,0,0),FC(1,1,1,0,1),FC(1,1,1,1,0),FC(1,1,1,1,1)
};
static const uint8_t TableC7[32] = {
    FC(0,0,0,0,0)<<7,FC(0,0,0,0,1)<<7,FC(0,0,0,1,0)<<7,FC(0,0,0,1,1)<<7,
    FC(0,0,1,0,0)<<7,FC(0,0,1,0,1)<<7,FC(0,0,1,1,0)<<7,FC(0,0,1,1,1)<<7,
    FC(0,1,0,0,0)<<7,FC(0,1,0,0,1)<<7,FC(0,1,0,1,0)<<7,FC(0,1,0,1,1)<<7,
    FC(0,1,1,0,0)<<7,FC(0,1,1,0,1)<<7,FC(0,1,1,1,0)<<7,FC(0,1,1,1,1)<<7,
    FC(1,0,0,0,0)<<7,FC(1,0,0,0,1)<<7,FC(1,0,0,1,0)<<7,FC(1,0,0,1,1)<<7,
    FC(1,0,1,0,0)<<7,FC(1,0,1,0,1)<<7,FC(1,0,1,1,0)<<7,FC(1,0,1,1,1)<<7,
    FC(1,1,0,0,0)<<7,FC(1,1,0,0,1)<<7,FC(1,1,0,1,0)<<7,FC(1,1,0,1,1)<<7,
    FC(1,1,1,0,0)<<7,FC(1,1,1,0,1)<<7,FC(1,1,1,1,0)<<7,FC(1,1,1,1,1)<<7
};

#define CRYPTO1_FILTER_OUTPUT_B7_24(O0,O1,O2) TableC7[abFilterTable[0][O0]|abFilterTable[1][O1]|abFilterTable[2][O2]]
#define CRYPTO1_FILTER_OUTPUT_B0_24(O0,O1,O2) TableC0[abFilterTable[0][O0]|abFilterTable[1][O1]|abFilterTable[2][O2]]

typedef struct {
    uint8_t Even[3];
    uint8_t Odd[3];
} Crypto1LfsrState_t;
static Crypto1LfsrState_t State = { {0}, {0} };

static inline uint8_t Crypto1LFSRbyteFeedback(uint8_t E0,uint8_t E1,uint8_t E2,uint8_t O0,uint8_t O1,uint8_t O2) {
    uint8_t Feedback;
    Feedback  = E0 & (uint8_t)(LFSR_MASK_EVEN);
    Feedback ^= E1 & (uint8_t)(LFSR_MASK_EVEN >> 8);
    Feedback ^= E2 & (uint8_t)(LFSR_MASK_EVEN >> 16);
    Feedback ^= O0 & (uint8_t)(LFSR_MASK_ODD);
    Feedback ^= O1 & (uint8_t)(LFSR_MASK_ODD >> 8);
    Feedback ^= O2 & (uint8_t)(LFSR_MASK_ODD >> 16);
    Feedback ^= ((Feedback >> 4) | (Feedback << 4));
    Feedback ^= Feedback >> 2;
    Feedback ^= Feedback >> 1;
    return Feedback;
}

void Crypto1Setup(uint8_t Key[6], uint8_t Uid[4], uint8_t CardNonce[4]) {
    uint8_t Even0=0,Even1=0,Even2=0;
    uint8_t Odd0=0,Odd1=0,Odd2=0;
    uint8_t KeyStream,Feedback,Out,In;

    KeyStream=Key[0]; SPLIT_BYTE(Even0,Odd0,KeyStream);
    KeyStream=Key[1]; SPLIT_BYTE(Even0,Odd0,KeyStream);
    KeyStream=Key[2]; SPLIT_BYTE(Even1,Odd1,KeyStream);
    KeyStream=Key[3]; SPLIT_BYTE(Even1,Odd1,KeyStream);
    KeyStream=Key[4]; SPLIT_BYTE(Even2,Odd2,KeyStream);
    KeyStream=Key[5]; SPLIT_BYTE(Even2,Odd2,KeyStream);

    for (int bc=0; bc<4; bc++) {
        In = CardNonce[bc] ^ Uid[bc];
        for (int bit=0; bit<8; bit++) {
            if (bit%2==0) {
                Out = CRYPTO1_FILTER_OUTPUT_B0_24(Odd0,Odd1,Odd2);
                SHIFT8(KeyStream,Out);
                Feedback = Crypto1LFSRbyteFeedback(Even0,Even1,Even2,Odd0,Odd1,Odd2) ^ (In & 1);
                In >>= 1;
                SHIFT24(Even0,Even1,Even2,Feedback);
            } else {
                Out = CRYPTO1_FILTER_OUTPUT_B0_24(Even0,Even1,Even2);
                SHIFT8(KeyStream,Out);
                Feedback = Crypto1LFSRbyteFeedback(Odd0,Odd1,Odd2,Even0,Even1,Even2) ^ (In & 1);
                In >>= 1;
                SHIFT24(Odd0,Odd1,Odd2,Feedback);
            }
        }
        CardNonce[bc] ^= KeyStream;
    }
    State.Even[0]=Even0; State.Even[1]=Even1; State.Even[2]=Even2;
    State.Odd[0]=Odd0; State.Odd[1]=Odd1; State.Odd[2]=Odd2;
}

void Crypto1Auth(uint8_t EncryptedReaderNonce[4]) {
    uint8_t Even0=State.Even[0],Even1=State.Even[1],Even2=State.Even[2];
    uint8_t Odd0=State.Odd[0],Odd1=State.Odd[1],Odd2=State.Odd[2];
    uint8_t In,Feedback;

    for (int i=0;i<4;i++) {
        In = EncryptedReaderNonce[i];
        for (int bit=0; bit<8; bit++) {
            if (bit%2==0) {
                Feedback = CRYPTO1_FILTER_OUTPUT_B0_24(Odd0,Odd1,Odd2);
                Feedback = Crypto1LFSRbyteFeedback(Even0,Even1,Even2,Odd0,Odd1,Odd2)^Feedback^(In&1);
                In>>=1;
                SHIFT24(Even0,Even1,Even2,Feedback);
            } else {
                Feedback = CRYPTO1_FILTER_OUTPUT_B0_24(Even0,Even1,Even2);
                Feedback = Crypto1LFSRbyteFeedback(Odd0,Odd1,Odd2,Even0,Even1,Even2)^Feedback^(In&1);
                In>>=1;
                SHIFT24(Odd0,Odd1,Odd2,Feedback);
            }
        }
    }
    State.Even[0]=Even0; State.Even[1]=Even1; State.Even[2]=Even2;
    State.Odd[0]=Odd0; State.Odd[1]=Odd1; State.Odd[2]=Odd2;
}

uint8_t Crypto1Byte(void) {
    uint8_t Even0=State.Even[0],Even1=State.Even[1],Even2=State.Even[2];
    uint8_t Odd0=State.Odd[0],Odd1=State.Odd[1],Odd2=State.Odd[2];
    uint8_t KeyStream,Feedback,Out;

    KeyStream = CRYPTO1_FILTER_OUTPUT_B7_24(Odd0,Odd1,Odd2);
    Feedback = Crypto1LFSRbyteFeedback(Even0,Even1,Even2,Odd0,Odd1,Odd2);
    SHIFT24(Even0,Even1,Even2,Feedback);

    for (int bit=1; bit<8; bit++) {
        if (bit%2==1) {
            Out = CRYPTO1_FILTER_OUTPUT_B7_24(Even0,Even1,Even2);
            KeyStream = (KeyStream>>1)|Out;
            Feedback = Crypto1LFSRbyteFeedback(Odd0,Odd1,Odd2,Even0,Even1,Even2);
            SHIFT24(Odd0,Odd1,Odd2,Feedback);
        } else {
            Out = CRYPTO1_FILTER_OUTPUT_B7_24(Odd0,Odd1,Odd2);
            KeyStream = (KeyStream>>1)|Out;
            Feedback = Crypto1LFSRbyteFeedback(Even0,Even1,Even2,Odd0,Odd1,Odd2);
            SHIFT24(Even0,Even1,Even2,Feedback);
        }
    }
    State.Even[0]=Even0; State.Even[1]=Even1; State.Even[2]=Even2;
    State.Odd[0]=Odd0; State.Odd[1]=Odd1; State.Odd[2]=Odd2;
    return KeyStream;
}

void Crypto1ByteArray(uint8_t *Buffer, uint8_t Count) {
    while (Count--) {
        *Buffer++ ^= Crypto1Byte();
    }
}

uint8_t Crypto1Nibble(void) {
    uint8_t ks = Crypto1Byte();
    return ks & 0x0F;
}
